# Keil uVision project Traffic.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Traffic
  c flags: Optim=4
  c include: .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Configuration
    ./: RTX_Conf_CM.c
  group Retarget
    ./: Retarget.c
  group Source
    ./: Getline.c Traffic.c GLCD_SPI_LPC1700.c LED.c KBD.c Serial.c
  group Documentation
    ./: Abstract.txt
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: Traffic
  c flags: Optim=4
  c include: .
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
